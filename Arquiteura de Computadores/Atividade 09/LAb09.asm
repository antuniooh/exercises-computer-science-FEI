org 0000h
	LJMP START

org 0003h
INT_0:	
	ACALL COMP
	CLR IE0
	RETI

org 0060h
COMP:
	MOV A, R2
	CJNE A, 98H, INCREMENTO
	MOV R2, #10
	ACALL INCREMENTO
	RET

INCREMENTO:
	DEC R2
	MOV A, R2
	MOV DPTR,#TABELA 
	MOVC A,@A+DPTR 
	MOV P1,A 
	RET

org 0080h
START:
	MOV R2, #10
	SETB EA
	SETB EX0
	SJMP $

TABELA: 
	DB 98H, 80H, 0F8H, 83H, 92H, 99H, 0B0H, 0A4H, 0F9H, 0C0H
 
